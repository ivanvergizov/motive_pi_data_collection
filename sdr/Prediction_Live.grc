options:
  parameters:
    generate_options: no_gui
    id: Prediction_Live
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filter1_high
    low_cutoff_freq: filter1_low
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filter2_high
    low_cutoff_freq: filter2_low
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 285e3
    low_cutoff_freq: 275e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 405e3
    low_cutoff_freq: 395e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '20000'
    max_iter: '4000'
    scale: 1/20000
    type: float
  states: {state: disabled}
- name: carrier_frequency
  id: parameter
  parameters:
    label: Carrier Frequency
    short_id: c
    type: eng_float
    value: 915e6
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, min_power_threshold=0, n_transmitters=2):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Prediction Block',   # will show up in GRC\n            in_sig=[np.float32] * int(n_transmitters),  \n            out_sig=[np.float32]\n        )\n        \n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.min_power_threshold = min_power_threshold\n        self.n_transmitters = int(n_transmitters)\n\t\n    def work(self, input_items, output_items):\n  \n    \tfor i in range(len(input_items[0])):\n    \t\n    \t\tpowers = [] \n    \t\tfor ch in range(self.n_transmitters): \n    \t\t\tpowers.append(input_items[ch][i])\n    \t\tpowers = np.array(powers)\n    \t\tif np.max(powers) < self.min_power_threshold:\n    \t\t\toutput_items[0][i] = -1\n    \t\telse:\n    \t\t\toutput_items[0][i] = float(np.argmax(powers))\n    \t\t\t\n    \treturn len(output_items[0])\n    \t\n        \n"
    min_power_threshold: '8e-7'
    n_transmitters: '2'
  states: {}
- name: filter1_high
  id: parameter
  parameters:
    label: 1st Filter High Cutoff
    short_id: z
    type: eng_float
    value: 90e3
  states: {}
- name: filter1_low
  id: parameter
  parameters:
    label: 1st Filter Low Cutoff
    short_id: x
    type: eng_float
    value: 80e3
  states: {}
- name: filter2_high
  id: parameter
  parameters:
    label: 2nd Filter High Cutoff
    short_id: u
    type: eng_float
    value: 205e3
  states: {}
- name: filter2_low
  id: parameter
  parameters:
    label: 2nd Filter Low Cutoff
    short_id: y
    type: eng_float
    value: 195e3
  states: {}
- name: node_id
  id: parameter
  parameters:
    label: Node Number
    short_id: n
    type: str
    value: '182'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: Receiver Gain
    short_id: g
    type: eng_float
    value: '30'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: a
    type: eng_float
    value: 2e6
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: carrier_frequency
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: '''192.168.2.'' + node_id'
    port: '8081'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '''tcp://192.168.2.'' +node_id+ '':55555'''
    timeout: '100'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_0_0, '0', epy_block_0, '1']
- [epy_block_0, '0', zeromq_pub_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', band_pass_filter_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
